Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: satino_black_soap_dispenser.ifc
Time: 2017-01-12T12:55:08
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Satino Black soap dispenser
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Satino Black soap dispenser; SKU (BO_prodsku): 180289; ManufacturName (BO_Manufac): Satino Black; ProductFamily (BO_prodfam): Sanitary; ProductGroup (BO_prodgroup): Dispenser; ManufacturCountry (BO_mancont): Netherlands; DesignCountry (BO_designcont): Netherlands; EditionNumber (BO_edinum): 1; Width (BO_width): 100; Height (BO_height): 290; Depth (BO_depth): 120; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/satinoblack/product/180289; ProductDataUrl (BO_prodaturl): bimobject.com/satinoblack/product/180289; EanCode (BO_ean): 8710561005117; MaterialMain (BO_mainmat): Plastic; BimObjectCategory (BO_bocat): Dispensers; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L8244; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary dispensers; Uniclass20Code (BO_uniclass_2_0_code): PR-35-76-75; Uniclass20Description (BO_uniclass_2_0_desc): Sanitary Towel Dispensers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_22; Uniclass2015Description (BO_uniclass2015_desc): Dispensers and acceptance units; NBSReference (BO_nbs_ref): 35-76-75; NBSReferenceDescription (BO_nbs_desc): Sanitary Towel Dispensers; OmniClassCode (BO_omniclass_code): 23-31 25 23 11; OmniClassDescription (BO_omniclass_name): Sanitary Napkin Dispensers; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
